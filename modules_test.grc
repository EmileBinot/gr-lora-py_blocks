options:
  parameters:
    generate_options: no_gui
    id: modules_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: CR
  id: variable
  parameters:
    value: '2'
  states: {}
- name: SF
  id: variable
  parameters:
    value: '9'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: '6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: dumpIN
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: dump
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: dumpOUT
    type: byte
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: dumpOUT
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: dumpIN
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: lora_frame
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2_0
  id: blocks_file_sink
  parameters:
    file: payloadOUT
    type: complex
  states: {}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    file: preamble
    type: complex
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (round(pow(2,SF)*(preamble_len+2.25)), 18*512)
    type: complex
  states: {state: disabled}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: (8, round(pow(2,SF)*(preamble_len+2.25)), 18*512)
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: pow(2,SF)
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_align_1
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"preambleStart"'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0, 0, 0, 0, 0, 0, 0, 0)
  states: {}
- name: blocks_vector_source_x_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x0e, 0x0d, 0x0c)
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (0xFF, 0x7F, 0x3F, 0x1F, 0x1F, 0x1F)
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: round(pow(2,SF)*(preamble_len+2.25))
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: pow(2,SF)
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    CR: CR
    SF: SF
    _source_code: |-
      """
      Interleaving block
      Scrambles bits together to fight error bursts.
      Reference : "Towards an SDR implementation of LoRa..." 2020 A.Marquet, N.Montavont, G.Papadopoulos)
      """

      import numpy as np
      from gnuradio import gr

      class Deinterleaver(gr.basic_block):
          def __init__(self, SF=9, CR=2):
              gr.basic_block.__init__(self,
                  name="LoRa Deinterleaver",
                  in_sig=[np.uint32],
                  out_sig=[np.uint8])
              self.SF = SF
              self.CR = CR

          def forecast(self, noutput_items, ninputs) :
              ninput_items_required = [self.CR+4]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
              return ninput_items_required

          def general_work(self, input_items, output_items):
              
              if(len(input_items[0]) >= self.CR+4) :

                  #buffer references
                  in0 = input_items[0][:self.CR+4]

                  # parsing in0 (convert + crop to CR+4 lines of SF bits and bundle in matrix)
                  input_matrix = np.zeros((self.CR+4, self.SF), dtype=np.uint8)
                  for i in range(len(in0)):
                      bits_crop = [int(x) for x in bin(in0[i])[2:]]        
                      bits_crop_norm = ([0]*(self.SF-len(bits_crop)) + bits_crop)[-(self.SF):]
                      input_matrix[i][:] = np.asarray(bits_crop_norm, dtype=np.uint8)

                  # deinterleaving
                  output_matrix = np.zeros((self.SF, self.CR+4), dtype=np.uint8)
                  for i in range(0,(self.SF)) :
                      for j in range(0,(self.CR+4)) :
                          idi=self.CR+4-1-j
                          idj=(self.SF-1-i+(self.CR+4)-1-j)%self.SF
                          output_matrix[i][j]=input_matrix[idi][idj]


                  # to uint32
                  output_items[0][0:(self.SF)] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))

                  # # debug
                  # print("\n--- GENERAL WORK : DEINTERLEAVER ---")
                  # print("in0 :")
                  # print(in0)
                  # print("len(in0) (should be CR+4): ")
                  # print(len(in0))
                  # print("input_matrix (CR+4 x SF):")
                  # print(input_matrix)
                  # print("output_matrix (SF x CR+4 ):")
                  # print(output_matrix)
                  # print("output_items[0] = ")
                  # print(output_items[0][0:(self.SF)])
                  # print("return len(output_items[0]) (should be CR+4): ")
                  # print(len(output_items[0]))

                  self.consume(0, self.CR+4)
                  # self.produce(0, self.SF-1)
                  return self.SF

              else :
                  return 0
  states: {}
- name: epy_block_0_1_0_0
  id: epy_block
  parameters:
    CR: CR
    SF: SF
    _source_code: "\"\"\"\nInterleaving block\nScrambles bits together to fight error bursts.\nReference : \"Towards an SDR implementation of LoRa...\" 2020 A.Marquet, N.Montavont, G.Papadopoulos)\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass Interleaver(gr.basic_block):\n    def __init__(self, SF=9, CR=4):\n        gr.basic_block.__init__(self,\n            name=\"LoRa Interleaver\",\n            in_sig=[np.uint8],\n            out_sig=[np.uint32])\n        self.SF = SF\n        self.CR = CR\n\n    def forecast(self, noutput_items, ninputs) :\n        #ninput_items_required[i] is the number of items that will be consumed on input port i\n        # we need SF items to produce anything\n        ninput_items_required = [self.SF]*ninputs \n        return ninput_items_required\n\n    def general_work(self, input_items, output_items):\n        \n        if(len(input_items[0]) >= self.SF) :\n\n            #buffer references\n            in0 = input_items[0][:self.SF]\n\n            # parsing in0 (convert + crop to SF lines of CR+4 bits and bundle in matrix)\n            input_matrix = np.zeros((self.SF, self.CR+4), dtype=np.uint8)\n            for i in range(len(in0)):\n                bits_crop = [int(x) for x in bin(in0[i])[2:]]        \n                bits_crop_norm = ([0]*(self.CR+4-len(bits_crop)) + bits_crop)[-(self.CR+4):]\n                input_matrix[i][:] = np.asarray(bits_crop_norm, dtype=np.uint8)\n\n            # interleaving\n            output_matrix = np.zeros((self.CR+4, self.SF), dtype=np.uint8)\n            for i in range(0,(self.CR+4)) :\n                for j in range(0,(self.SF)) :\n                    idi=self.SF-1-(j-i)%self.SF\n                    idj=self.CR+4-1-i\n                    output_matrix[i][j]=input_matrix[idi][idj]\n            \n            # to uint32\n            output_items[0][0:(self.CR+4)] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))\n\n            # # debug\n            # print(\"\\n--- GENERAL WORK : INTERLEAVER ---\")\n            # print(\"in0 :\")\n            # print(in0)\n            # print(\"len(in0) (should be SF): \")\n            # print(len(in0))\n            # print(\"input_matrix (SF x CR+4):\")\n            # print(input_matrix)\n            # print(\"output_matrix (CR+4 x SF):\")\n            # print(output_matrix)\n            # print(\"output_items[0] = \")\n            # print(output_items[0])\n\n            #consume inputs (should be SF)\n            self.consume(0, self.SF)\n            # return produced outputs (should be CR+4)\n            return self.CR+4\n\n        else :\n            return 0\n\n\n\n"
  states: {}
- name: epy_block_0_1_0_0_0
  id: epy_block
  parameters:
    B: '250000'
    SF: SF
    _source_code: "\"\"\"\nLoRa sync block\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport math\n\n\ndef modulate(SF, id, os_factor) :\n    M  = pow(2,SF)\n    n_fold = M * os_factor - id * os_factor\n    chirp = np.zeros(M*os_factor, dtype=np.complex64)\n    for n in range(0,M*os_factor):\n        if n < n_fold:\n            chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-0.5)*n/os_factor))\n        else:\n            chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-1.5)*n/os_factor))\n    return chirp\n\nclass Sync(gr.basic_block):\n    def __init__(self, SF=9, B=250000, preamble_len= 6):\n        gr.basic_block.__init__(self,\n            name=\"LoRa Sync\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64])\n        self.SF = SF\n        self.currentState = 'WAIT'\n        self.B = B\n        self.preamble_len = preamble_len\n        self.receivedBlocksCounter = 1\n\n    def forecast(self, noutput_items, ninputs) :\n        #ninput_items_required[i] is the number of items that will be consumed on input port i\n        # we need 2^SF items to produce anything\n        ninput_items_required = [pow(2,self.SF)]*ninputs \n        return ninput_items_required\n\n    def general_work(self, input_items, output_items):\n        M = pow(2,self.SF)\n        threshold = M/2\n        syncword = 0\n\n        if(len(input_items[0]) >= pow(2,self.SF)) :\n\n            base_upchirp = modulate(self.SF, 0, 1)\n            base_downchirp = np.conjugate(base_upchirp)\n            demod_signal = np.multiply(input_items[0][:M], base_downchirp)\n            demod_signal_fft = np.fft.fft(demod_signal)\n            peak = int(np.max(np.abs(demod_signal_fft)))\n            idx = np.argmax(np.abs(demod_signal_fft))\n            freq_vect = np.arange(0,M-1)*(self.B/M) # !!!! WILL INTRODUCE PROBLEMS WHEN OS_FACTOR IS NOT 1 !!!!\n            symbols_hat = round(freq_vect[idx]*M/self.B)\n            \n            if(self.currentState == 'WAIT') :\n                if peak > threshold :\n                    self.currentState = 'UPCHIRPS'\n                else :\n                    self.consume(0, M)\n\n            if self.currentState == 'UPCHIRPS' :\n                if peak < threshold :\n                    self.currentState = 'WAIT'\n                f_up = idx\n                if idx == 0 :\n                    self.receivedBlocksCounter += 1\n                    if self.receivedBlocksCounter >= self.preamble_len-2 :\n                        self.currentState = 'SYNCWORD'\n                self.consume(0, M)\n\n            if self.currentState == 'SYNCWORD' :\n                if peak < threshold :\n                    self.currentState = 'WAIT'\n                if idx == syncword :\n                    self.receivedBlocksCounter += 1\n                if self.receivedBlocksCounter >= self.preamble_len :\n                    self.currentState = 'DOWNCHIRPS'\n                self.consume(0, M)\n\n            if self.currentState == 'DOWNCHIRPS' :\n                demod_signal = np.multiply(input_items[0][:M], base_upchirp)\n                demod_signal_fft = np.fft.fft(demod_signal)\n                peak = int(np.max(np.abs(demod_signal_fft)))\n                idx = np.argmax(np.abs(demod_signal_fft))\n                freq_vect = np.arange(0,M-1)*(self.B/M) # !!!! WILL INTRODUCE PROBLEMS WHEN OS_FACTOR IS NOT 1 !!!!\n                f_down = idx\n                self.receivedBlocksCounter += 1\n\n                if self.receivedBlocksCounter > self.preamble_len+2 :\n                    self.consume(0, M*0.25)\n                    self.currentState = 'SYNC'\n                else : \n                    self.consume(0, M)\n            if self.currentState == 'SYNC' :\n                CFOint = ((f_down + f_up)/2)*self.B\n                STOint = (1-(f_down + f_up)/2)*M\n                output_items[0][0:M] = input_items[0][0:M] # pass thru\n                self.consume(0, M)\n\n            print(\"\\n--- Frame Sync ---\")\n            print(self.currentState)\n            print(\"receivedBlockCounter: \", self.receivedBlocksCounter)\n            print(\"idx: \", idx)\n            print(\"peak: \", peak)\n\n\n            \n            return 0\n        else :\n            return 0\n\n\n\n"
    preamble_len: preamble_len
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    CR: CR
    _source_code: |-
      """
      Hamming Decoding block
      Forward Error Correction encoding block
      Reference : "Towards an SDR implementation of LoRa..." 2020 A.Marquet, N.Montavont, G.Papadopoulos)
      """

      import numpy as np
      from gnuradio import gr


      class Hamming_Rx(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, CR = 2):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LoRa Hamming Rx',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.CR = CR

          def decode(self, input_vect, CR_loc) : 

              output=input_vect

              if CR_loc == 1:
                  syndrome = input_vect[0] ^ input_vect[1] ^ input_vect[2] ^ input_vect[3] ^ input_vect[4]
                  output = input_vect

              if CR_loc == 2:
                  syndrome = np.zeros((2,1), dtype=np.uint8)
                  syndrome[0] = input_vect[0] ^ input_vect[1] ^ input_vect[2] ^ input_vect[5]
                  syndrome[1] = input_vect[1] ^ input_vect[2] ^ input_vect[3] ^ input_vect[4]
                  output = input_vect

              if CR_loc == 3:
                  n = 4+CR_loc
                  k = 4
                  Q = np.array([[0,1,1], [1,1,0], [1,1,1], [1,0,1]], np.uint8)
                  Id = np.identity(n-k, dtype=np.uint8)
                  H = np.concatenate((Q.transpose(), Id),axis=1)
                  syndrome = np.dot(input_vect[:], H.transpose())%2

                  tmp = np.zeros((1,n-k+4), dtype=np.uint8)
                  tmp2 = np.identity(n-k+4, dtype=np.uint8)
                  E = np.concatenate((tmp, tmp2),axis=0)
                  S = np.dot(E,H.transpose())%2

                  # if(syndrome[0] == 1 or syndrome[1] == 1):
                  #     print("Error detected, correcting...")

                  for j in range(S.shape[1]):
                      if np.array_equal(S[j],syndrome):
                          output = input_vect ^ E[j][:]


              if CR_loc == 4:
                  n = 4+CR_loc
                  k = 4
                  Q = np.array([[0,1,1,1], [1,1,0,1], [1,1,1,0], [1,0,1,1]], np.uint8)
                  Id = np.identity(n-k, dtype=np.uint8)
                  H = np.concatenate((Q.transpose(), Id),axis=1)
                  syndrome = np.dot(input_vect[:], H.transpose())%2
                  if np.array_equal(syndrome,np.array([0,0,0,0])):
                      output = input_vect
                      # print("no error detected")

                  else :
                      parity = input_vect[0] ^ input_vect[1] ^ input_vect[2] ^ input_vect[3] ^ input_vect[4] ^ input_vect[5] ^ input_vect[6] ^ input_vect[7]

                      if parity :
                          # print("1 error detected, sending to hamming(7,3)")
                          output = self.decode(input_vect[:][0:7], 3)
                      # else :
                          # print("2 errors detected")
                      
              
              return output[:][0:4]

          def work(self, input_items, output_items):

              in0 = input_items[0]
              out = output_items[0]
          
              # Hamming encoding (iterate over matrix lines and encode each)
              output_matrix = np.zeros((len(in0), 4), dtype=np.uint8)
              input_matrix = np.zeros((len(in0), 4+self.CR), dtype=np.uint8)

              for i in range(len(in0)):

                  # parsing in0 (convert + crop to lines of 4 bits and bundle in matrix)
                  bits_crop = [int(x) for x in bin(in0[i])[2:]]        
                  bits_crop_norm = ([0]*(self.CR+4-len(bits_crop)) + bits_crop)[-(self.CR+4):]
                  input_matrix[i][:] = np.asarray(bits_crop_norm, dtype=np.uint8)

                  output_matrix[i][:] = self.decode(input_matrix[i][:],self.CR)


              # convert output matrix to uint8
              out[:] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))

              # # debug
              # print("\n--- GENERAL WORK : HAMMING_DEC ---")
              # print("in0 :")
              # print(in0)
              # print("input_matrix :")
              # print(input_matrix)
              # print("output_matrix :")
              # print(output_matrix)
              # print("out :")
              # print(out)
              # print("--- HAMMING_DEC END---")

              return len(output_items[0])
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Whitening block
      Whiten input sequence to remove the frequency and time correlations in it.

      """
      import numpy as np
      from gnuradio import gr

      whitening_seq =(0xFF, 0xFE, 0xFC, 0xF8, 0xF0, 0xE1, 0xC2, 0x85, 0x0B, 0x17, 0x2F, 0x5E, 0xBC, 0x78, 0xF1, 0xE3,
                      0xC6, 0x8D, 0x1A, 0x34, 0x68, 0xD0, 0xA0, 0x40, 0x80, 0x01, 0x02, 0x04, 0x08, 0x11, 0x23, 0x47,
                      0x8E, 0x1C, 0x38, 0x71, 0xE2, 0xC4, 0x89, 0x12, 0x25, 0x4B, 0x97, 0x2E, 0x5C, 0xB8, 0x70, 0xE0,
                      0xC0, 0x81, 0x03, 0x06, 0x0C, 0x19, 0x32, 0x64, 0xC9, 0x92, 0x24, 0x49, 0x93, 0x26, 0x4D, 0x9B,
                      0x37, 0x6E, 0xDC, 0xB9, 0x72, 0xE4, 0xC8, 0x90, 0x20, 0x41, 0x82, 0x05, 0x0A, 0x15, 0x2B, 0x56,
                      0xAD, 0x5B, 0xB6, 0x6D, 0xDA, 0xB5, 0x6B, 0xD6, 0xAC, 0x59, 0xB2, 0x65, 0xCB, 0x96, 0x2C, 0x58,
                      0xB0, 0x61, 0xC3, 0x87, 0x0F, 0x1F, 0x3E, 0x7D, 0xFB, 0xF6, 0xED, 0xDB, 0xB7, 0x6F, 0xDE, 0xBD,
                      0x7A, 0xF5, 0xEB, 0xD7, 0xAE, 0x5D, 0xBA, 0x74, 0xE8, 0xD1, 0xA2, 0x44, 0x88, 0x10, 0x21, 0x43,
                      0x86, 0x0D, 0x1B, 0x36, 0x6C, 0xD8, 0xB1, 0x63, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xF3, 0xE7, 0xCE,
                      0x9C, 0x39, 0x73, 0xE6, 0xCC, 0x98, 0x31, 0x62, 0xC5, 0x8B, 0x16, 0x2D, 0x5A, 0xB4, 0x69, 0xD2,
                      0xA4, 0x48, 0x91, 0x22, 0x45, 0x8A, 0x14, 0x29, 0x52, 0xA5, 0x4A, 0x95, 0x2A, 0x54, 0xA9, 0x53,
                      0xA7, 0x4E, 0x9D, 0x3B, 0x77, 0xEE, 0xDD, 0xBB, 0x76, 0xEC, 0xD9, 0xB3, 0x67, 0xCF, 0x9E, 0x3D,
                      0x7B, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFA, 0xF4, 0xE9, 0xD3, 0xA6, 0x4C, 0x99, 0x33, 0x66,
                      0xCD, 0x9A, 0x35, 0x6A, 0xD4, 0xA8, 0x51, 0xA3, 0x46, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
                      0x0E, 0x1D, 0x3A, 0x75, 0xEA, 0xD5, 0xAA, 0x55, 0xAB, 0x57, 0xAF, 0x5F, 0xBE, 0x7C, 0xF9, 0xF2,
                      0xE5, 0xCA, 0x94, 0x28, 0x50, 0xA1, 0x42, 0x84, 0x09, 0x13, 0x27, 0x4F, 0x9F, 0x3F, 0x7F)

      whitening_seq_debug =0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF

      whitening_seq = whitening_seq_debug

      class Whitening(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LoRa Whitening',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.table_idx = 0
              
          def work(self, input_items, output_items):
              
              in0 = input_items[0]
              out = output_items[0]
              # parsing in0 (convert + crop to lines of 4 bits and bundle in matrix)
              input_matrix = np.zeros((len(in0), 4), dtype=np.uint8)
              for i in range(len(in0)):
                  bits_crop = [int(x) for x in bin(in0[i])[2:]]        
                  bits_crop_norm = ([0]*(4-len(bits_crop)) + bits_crop)[-(4):]
                  input_matrix[i][:] = np.asarray(bits_crop_norm, dtype=np.uint8)
                  
                  # whitening
                  out[i] = in0[i] ^ whitening_seq[self.table_idx]
                  self.table_idx += 1
                  if(self.table_idx == len(whitening_seq)):
                      self.table_idx = 0


              # #debug
              # print("\n--- GENERAL WORK : WHITENING ---")
              # print("in0 :")
              # print(in0)
              # print("input_matrix :")
              # print(input_matrix)
              # print("out :")
              # print(out)
              # print("return len(out): ")
              # print(len(out))
              # print("--- WHITENING END---")

              return len(out)
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    CR: CR
    _source_code: |
      """
      Hamming encoding block
      Forward Error Correction encoding block
      Reference : "Towards an SDR implementation of LoRa..." 2020 A.Marquet, N.Montavont, G.Papadopoulos)
      """

      import numpy as np
      from gnuradio import gr


      class Hamming_enc(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, CR = 4):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LoRa Hamming Tx',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.CR = CR

          def work(self, input_items, output_items):
              
              in0 = input_items[0]
              out = output_items[0]
          
              # Hamming encoding (iterate over matrix lines and encode each)
              output_matrix = np.zeros((len(in0), 4+self.CR), dtype=np.uint8)
              input_matrix = np.zeros((len(in0), 4), dtype=np.uint8)
              for i in range(len(in0)):

                  # parsing in0 (convert + crop to lines of 4 bits and bundle in matrix)
                  bits_crop = [int(x) for x in bin(in0[i])[2:]] 
                  # print(bits_crop)      
                  bits_crop_norm = ([0]*(4-len(bits_crop)) + bits_crop)[-(4):]
                  input_matrix[i][:] = np.asarray(bits_crop_norm, dtype=np.uint8)

                  if self.CR == 1:
                      p0 = input_matrix[i][0] ^ input_matrix[i][1] ^ input_matrix[i][2] ^ input_matrix[i][3]
                      output_matrix[i] = np.asarray([input_matrix[i][0], input_matrix[i][1], input_matrix[i][2], input_matrix[i][3], p0], dtype=np.uint8)

                  if self.CR == 2:
                      p0 = input_matrix[i][0] ^ input_matrix[i][1] ^ input_matrix[i][2]
                      p1 = input_matrix[i][1] ^ input_matrix[i][2] ^ input_matrix[i][3]
                      output_matrix[i] = np.asarray([input_matrix[i][0], input_matrix[i][1], input_matrix[i][2], input_matrix[i][3], p1, p0], dtype=np.uint8)

                  if self.CR == 3:
                      Q = np.array([[0,1,1,1], [1,1,0,1], [1,1,1,0], [1,0,1,1]], np.uint8)
                      Id = np.identity(4, dtype=np.uint8)
                      G = np.concatenate((Id, Q),axis=1)
                      output_matrix[i] = (np.dot(input_matrix[i],G)%2)[0:4+self.CR]

                  if self.CR == 4:
                      Q = np.array([[0,1,1,1], [1,1,0,1], [1,1,1,0], [1,0,1,1]], np.uint8)
                      Id = np.identity(4, dtype=np.uint8)
                      G = np.concatenate((Id, Q),axis=1)
                      output_matrix[i] = (np.dot(input_matrix[i],G)%2)

              # convert output matrix to uint8
              out[:] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))

              # #debug
              # print("\n--- GENERAL WORK : HAMMING_ENC ---")
              # print("in0 :")
              # print(in0)
              # print("input_matrix :")
              # print(input_matrix)
              # print("output_matrix :")
              # print(output_matrix)
              # print("out :")
              # print(out)
              # print("--- HAMMING_ENC END---")

              return len(output_items[0])
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Dewhitening block
      """
      import numpy as np
      from gnuradio import gr

      whitening_seq =(0xFF, 0xFE, 0xFC, 0xF8, 0xF0, 0xE1, 0xC2, 0x85, 0x0B, 0x17, 0x2F, 0x5E, 0xBC, 0x78, 0xF1, 0xE3,
                      0xC6, 0x8D, 0x1A, 0x34, 0x68, 0xD0, 0xA0, 0x40, 0x80, 0x01, 0x02, 0x04, 0x08, 0x11, 0x23, 0x47,
                      0x8E, 0x1C, 0x38, 0x71, 0xE2, 0xC4, 0x89, 0x12, 0x25, 0x4B, 0x97, 0x2E, 0x5C, 0xB8, 0x70, 0xE0,
                      0xC0, 0x81, 0x03, 0x06, 0x0C, 0x19, 0x32, 0x64, 0xC9, 0x92, 0x24, 0x49, 0x93, 0x26, 0x4D, 0x9B,
                      0x37, 0x6E, 0xDC, 0xB9, 0x72, 0xE4, 0xC8, 0x90, 0x20, 0x41, 0x82, 0x05, 0x0A, 0x15, 0x2B, 0x56,
                      0xAD, 0x5B, 0xB6, 0x6D, 0xDA, 0xB5, 0x6B, 0xD6, 0xAC, 0x59, 0xB2, 0x65, 0xCB, 0x96, 0x2C, 0x58,
                      0xB0, 0x61, 0xC3, 0x87, 0x0F, 0x1F, 0x3E, 0x7D, 0xFB, 0xF6, 0xED, 0xDB, 0xB7, 0x6F, 0xDE, 0xBD,
                      0x7A, 0xF5, 0xEB, 0xD7, 0xAE, 0x5D, 0xBA, 0x74, 0xE8, 0xD1, 0xA2, 0x44, 0x88, 0x10, 0x21, 0x43,
                      0x86, 0x0D, 0x1B, 0x36, 0x6C, 0xD8, 0xB1, 0x63, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xF3, 0xE7, 0xCE,
                      0x9C, 0x39, 0x73, 0xE6, 0xCC, 0x98, 0x31, 0x62, 0xC5, 0x8B, 0x16, 0x2D, 0x5A, 0xB4, 0x69, 0xD2,
                      0xA4, 0x48, 0x91, 0x22, 0x45, 0x8A, 0x14, 0x29, 0x52, 0xA5, 0x4A, 0x95, 0x2A, 0x54, 0xA9, 0x53,
                      0xA7, 0x4E, 0x9D, 0x3B, 0x77, 0xEE, 0xDD, 0xBB, 0x76, 0xEC, 0xD9, 0xB3, 0x67, 0xCF, 0x9E, 0x3D,
                      0x7B, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFA, 0xF4, 0xE9, 0xD3, 0xA6, 0x4C, 0x99, 0x33, 0x66,
                      0xCD, 0x9A, 0x35, 0x6A, 0xD4, 0xA8, 0x51, 0xA3, 0x46, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
                      0x0E, 0x1D, 0x3A, 0x75, 0xEA, 0xD5, 0xAA, 0x55, 0xAB, 0x57, 0xAF, 0x5F, 0xBE, 0x7C, 0xF9, 0xF2,
                      0xE5, 0xCA, 0x94, 0x28, 0x50, 0xA1, 0x42, 0x84, 0x09, 0x13, 0x27, 0x4F, 0x9F, 0x3F, 0x7F)

      whitening_seq_debug = 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF

      whitening_seq = whitening_seq_debug

      class LoRa_Dewhitening(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LoRa Dewhitening',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.table_idx = 0
              
          def work(self, input_items, output_items):


              in0 = input_items[0]
              out = output_items[0]
              # parsing in0 (convert + crop to lines of 4 bits and bundle in matrix)
              input_matrix = np.zeros((len(in0), 4), dtype=np.uint8)
              for i in range(len(in0)):
                  bits_crop = [int(x) for x in bin(in0[i])[2:]]        
                  bits_crop_norm = ([0]*(4-len(bits_crop)) + bits_crop)[-(4):]
                  input_matrix[i][:] = np.asarray(bits_crop_norm, dtype=np.uint8)
                  
                  # dewhitening
                  out_temp = in0[i] ^ whitening_seq[self.table_idx]
                  bits_out_temp_crop = [int(x) for x in bin(out_temp)[2:]]        
                  bits_out_temp_crop_norm = ([0]*(4-len(bits_out_temp_crop)) + bits_out_temp_crop)[-(4):]
                  # print(bits_out_temp_crop_norm)
                  output_items[0][i] = np.array(bits_out_temp_crop_norm).dot(1 << np.arange(np.array(bits_out_temp_crop_norm).shape[-1] - 1, -1, -1))
                  self.table_idx += 1
                  if(self.table_idx == len(whitening_seq)):
                      self.table_idx = 0

              # #debug
              # print("\n--- GENERAL WORK : DEWHITENING ---")
              # print("in0 :")
              # print(in0)
              # print("input_matrix :")
              # print(input_matrix)
              # print("out :")
              # print(output_items[0][:])
              # print("return len(out): ")
              # print(len(output_items[0]))
              # print("--- DEWHITENING END---")
              return len(output_items[0])
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    SF: '9'
    _source_code: |-
      """
      Modulation Block:
      """

      import numpy as np
      from gnuradio import gr
      import math

      def modulate(SF, id, os_factor) :
          M  = pow(2,SF)
          chirp = np.zeros((len(id),M*os_factor), dtype=np.complex64)

          for i in range(len(id)) :
              n_fold = M * os_factor - id[i] * os_factor
              for n in range(0,M*os_factor):
                  if n < n_fold:
                      chirp[i][n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id[i]/M-0.5)*n/os_factor))
                  else:
                      chirp[i][n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id[i]/M-1.5)*n/os_factor))
          
          # chirp = np.reshape(chirp,-1)

          return chirp

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, SF = 9, preamble_len = 6):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LoRa Preamble',   # will show up in GRC
                  in_sig=None,
                  # out_sig=[(np.complex64,pow(2,SF)*preamble_len+round(pow(2,SF)*2.25))]
                  out_sig=[(np.complex64,round(pow(2,SF)*(preamble_len+2.25)))]
              )
              self.SF = SF
              self.preamble_len = preamble_len

          def work(self, input_items, output_items):

              # for i in range (len(symbols)) :
              #     output_items[0][i] = modulate(self.SF, [symbols[i]], 1)
              
              # preamble = np.zeros((self.preamble_len*pow(2,self.SF)), dtype=np.complex64)
              preamble_up = np.reshape(modulate(self.SF, [0]*self.preamble_len, 1), -1)
              preamble_down = np.reshape(np.conjugate(modulate(self.SF, [0]*3, 1)), -1)[0:int(2.25*pow(2,self.SF))]
              #  [:round(0.75*pow(2,self.SF))]
              # print(preamble_up.shape)
              # print(preamble_down.shape)
              preamble = np.concatenate((preamble_up, preamble_down))
              output_items[0][0] = np.reshape(preamble,-1)


              return len(output_items[0])
    preamble_len: preamble_len
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class my_basic_adder_block(gr.basic_block):
          # def __init__(self):
          #     gr.basic_block.__init__(self,
          #         name="test_blqsdock",
          #         in_sig=[np.uint8],
          #         out_sig=[np.uint8])

          # def forecast(self, noutput_items, ninputs) :
          #     ninput_items_required = [0]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
          #     for i in range(ninputs):
          #         ninput_items_required[i] = 1.5 * noutput_items * ninputs

          #     # print("--- FORECAST ---")
          #     # print(ninputs)
          #     # print(noutput_items)
          #     # print(ninput_items_required)

          #     return ninput_items_required


          # def general_work(self, input_items, output_items):
              
          #     #buffer references
          #     in0 = input_items[0][:len(output_items[0])]
          #     out = output_items[0]
              

          #     output_items[0][:] = in0


          #     print("\n--- GENERAL WORK 1  ---")
          #     print("input_items[0]")
          #     print(input_items[0])
          #     print("in0")
          #     print(in0)
          #     print("len(in0)")
          #     print(len(in0))
          #     print("output_items[0]")
          #     print(output_items[0])
          #     print("len(output_items[0])")
          #     print(len(output_items[0]))

          #     #consume the inputs
          #     self.consume(0, len(in0)) #consume port 0 input
          #     # self.produce(0, 1) #produce 3 items on port 0
          #     #return produced
          #     return len(output_items[0])

         def __init__(self, input_buffer_len=2):
            gr.basic_block.__init__(self,
               name="sync_test",
               in_sig=[np.uint8],
               out_sig=[np.uint8])
            self.input_buffer_len = input_buffer_len

         def forecast(self, noutput_items, ninputs):
          #   print("FORECAST START")
            ninput_items_required = [self.input_buffer_len] * ninputs
          #   print("len(ninput_items_required),noutput_items",len(ninput_items_required),noutput_items)
          #   print("FORECAST END")
            return ninput_items_required

         def general_work(self, input_items, output_items):
          print("\n--- GENERAL WORK START ---")
          if(len(input_items[0]) >= self.input_buffer_len) :
              out_vect = [0xFF, 0x55, 0xAA]
              output_items[0][0:len(out_vect)] = out_vect
              self.consume(0, self.input_buffer_len)
              self.produce(0, len(out_vect))


              print("len(input_items)", len(input_items[0]))
              print("input_buffer_len", self.input_buffer_len)
              print("len(input_items[0]) >= input_buffer_len")
              print("len(output_items[0])", len(output_items[0]))
              print("output_items[0] = ")
              print(output_items[0])

          print("--- GENERAL WORK END ---")
          return len(out_vect)
    input_buffer_len: '2'
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    B: '250000'
    SF: SF
    _source_code: |
      """
      Demodulation Block:
      """

      import numpy as np
      from gnuradio import gr
      import math

      # def modulate(SF, symbol, sign) :
          # M  = pow(2,SF)
          # ka = np.arange(0,M)
          # fact1 = np.exp(1j*sign*math.pi*pow(ka,2)/M)
          # fact1 = np.reshape(fact1,(1,-1))
          # symbK = np.multiply(fact1,np.exp(2j*math.pi*(symbol/M)*ka))
          # return symbK
          
      def modulate(SF, id, os_factor) :
          M  = pow(2,SF)
          n_fold = M * os_factor - id * os_factor
          chirp = np.zeros(M*os_factor, dtype=np.complex64)
          for n in range(0,M*os_factor):
              if n < n_fold:
                  chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-0.5)*n/os_factor))
              else:
                  chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-1.5)*n/os_factor))
          return chirp


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, SF = 9, B = 250000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='LoRa Demodulation',   # will show up in GRC
                  in_sig=[(np.complex64,pow(2,SF))],
                  # out_sig=[(np.complex64,512)]
                  out_sig=[np.uint32]
              )
              self.SF = SF
              self.B = B

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              base_upchirp = modulate(self.SF, 0, 1)
              base_downchirp = np.conjugate(base_upchirp)
              M = pow(2,self.SF)
              symbols_hat =  np.zeros(len(input_items[0]), dtype=np.uint32)
              for i in range(len(input_items[0])):
                  demod_signal = np.multiply(input_items[0][i], base_downchirp)
                  demod_signal_fft = np.fft.fft(demod_signal)
                  idx = np.argmax(np.abs(demod_signal_fft))
                  freq_vect = np.arange(0,M-1)*(self.B/M) # !!!! WILL INTRODUCE PROBLEMS WHEN OS_FACTOR IS NOT 1 !!!!
                  output_items[0][i] = round(freq_vect[idx]*M/self.B)
                  symbols_hat[i] = round(freq_vect[idx]*M/self.B)
              
              # debug
              print("\n--- GENERAL WORK : DEMODULATION ---")
              print("symbols_hat :")
              print(symbols_hat)

              return len(output_items[0])
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    SF: '9'
    _source_code: |-
      """
      Frame_sync block
      Correlation method
      """

      from readline import set_history_length
      import numpy as np
      from gnuradio import gr
      import pmt

      class Frame_sync(gr.basic_block):
          def __init__(self, SF=9, preamble_len = 6, frameLength = 18):
              gr.basic_block.__init__(self,
                  name="LoRa Frame Detector",
                  in_sig=[np.complex64,(np.complex64, round(pow(2,SF)*(preamble_len+2.25)))], # first input is the input signal, second is the preamble to be correlated with
                  # out_sig=[(np.complex64,pow(2,SF))])
                  out_sig=[(np.complex64)])
              self.SF = SF
              self.fullPreambleLength = round(pow(2,SF)*(preamble_len+2.25))
              self.frameLength = round(pow(2,SF)*(frameLength))
              set_history_length(self.fullPreambleLength)

          def forecast(self, noutput_items, ninputs) :
              ninput_items_required = [1]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
              return ninput_items_required

          def general_work(self, input_items, output_items):
              preamble_detected = False
              offset = 0

              #buffer references
              in0 = input_items[0] #input signal
              in1 = input_items[1] #preamble to be correlated with

              Corr = np.correlate(in0[:], in1[0])
              peak = np.max(Corr)
              peakIndex = np.argmax(Corr)
              threshold = 2000
              # print("\n--- Correlator ---")
              # print("Peak: ", peak)
              # print("Peak Index: ", peakIndex)
              # print("output_items[0]: ", len(output_items[0]))

              if peak > threshold :
                  # print("peak > threshold")
                  self.add_item_tag(0, self.nitems_written(0) + self.fullPreambleLength + peakIndex,  pmt.intern("preambleStart"),  pmt.intern(str(self.frameLength)))
                  output_items[0][0:len(in0)] = in0[:len(output_items[0])]
                  self.consume(0, len(in0[:len(output_items[0])]))
                  # print("consumed: ", len(in0[:len(output_items[0])]))
                  return len(in0[:len(output_items[0])])

              else :
                  output_items[0][0:len(in0)] = in0[:len(output_items[0])]
                  self.consume(0, len(in0[:len(output_items[0])]))
                  # print("consumed: ", len(in0[:len(output_items[0])]))
                  return len(in0[:len(output_items[0])])

              # if preamble_detected :
              #     print("preamble_detected")
              #     self.consume(0, offset) # consume till offset
              #     pass
              # else :
              #     print("preamble_NOT_detected")
              #     self.consume(0, self.in_len) # consume all input items
              #     return 0

              # # parsing in0 (convert + crop t
              # # to uint32
              # output_items[0][0:(self.CR+4)] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))

              # #consume inputs (should be SF)
              # self.consume(0, self.SF)
              # return self.CR+4
    frameLength: '18'
    preamble_len: preamble_len
  states: {}
- name: epy_block_6_0
  id: epy_block
  parameters:
    _source_code: |-
      # """
      # Preamble removal block
      # Correlation method
      # """

      # import numpy as np
      # from gnuradio import gr
      # import pmt

      # class Preamble_Remover(gr.basic_block):
      #     def __init__(self, SF=9, preamble_len = 6):
      #         gr.basic_block.__init__(self,
      #             name="LoRa Preamble Remover",
      #             in_sig=[(np.complex64)],
      #             out_sig=[(np.complex64)])
      #         self.SF = SF

      #     def forecast(self, noutput_items, ninputs) :
      #         ninput_items_required = [1]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
      #         return ninput_items_required

      #     def general_work(self, input_items, output_items):

      #         #buffer references
      #         in0 = input_items[0] #input signal

      #         tags = self.get_tags_in_window(0, 0, len(input_items[0]))
      #         for tag in tags:
      #             key = pmt.to_python(tag.key) # convert from PMT to python string
      #             value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
      #             print('key:', key)
      #             print('value:', value, type(value))
      #             print('')
      #             croppedInput = in0[int(value):]
      #             output_items[0][0:len(in0)] = croppedInput[:len(output_items[0])]
      #             self.consume(0, len(in0[:len(output_items[0])]))
      #         return len(in0[:len(output_items[0])])

      import numpy as np
      from gnuradio import gr
      import pmt

      class my_basic_adder_block(gr.basic_block):
          def __init__(self,tag_name = 'packet_len'):
              gr.basic_block.__init__(self,
                                      name="Tagged Stream Cropper",
                                      in_sig  = [np.complex64],
                                      out_sig = [np.complex64])

              self.previous_tag_n_remainder = 0
              self.tag_name                 = tag_name
              self.set_tag_propagation_policy(gr.TPP_DONT)


          def general_work(self, input_items, output_items):
              len_out = len(output_items[0])

              # DO PROCESSING
              out_produced = 0 # output produced 

              #-> Write the remaining data of the previous tag
              if self.previous_tag_n_remainder > 0: 
                  if self.previous_tag_n_remainder < len_out: # if the length of the input items is sufficient to write the remainder of the previous tag items 
                      output_items[0][:self.previous_tag_n_remainder] = input_items[0][:self.previous_tag_n_remainder] #write to output 
                      out_produced                                   += self.previous_tag_n_remainder                  #inccrease the number of item produced
                      self.previous_tag_n_remainder = 0                                                                #reset the counter 
                      # the RETURN is at the end of the work()

                  else: # self.previous_tag_n_remainder >= len_out
                      output_items[0][:len_out]      = input_items[0][:len_out]
                      self.previous_tag_n_remainder -= len_out
                      self.consume(0, len_out)
                      return len_out

              # READ TAGS AND PARSE THE RECEIVED STREAM
              tags = self.get_tags_in_window(0, out_produced, len_out)

              #if there exist tag
              if len(tags) > 0:
                  #for each tag apply
                  for tag in tags:
                      tag_name   = pmt.to_python(tag.key)            # packet_tag
                      tag_len    = int(pmt.to_python(tag.value))          # packet_len
                      tag_pos    = tag.offset - self.nitems_read(0)  # packet_position_index
                      if tag_name == self.tag_name:       #check if the tag name is appropriate
                          if tag_pos + tag_len < len_out: # if all the elements correspding to the "tag" are included in the input_items

                              # write the elements to the output
                              output_items[0][out_produced:(out_produced+tag_len)] = input_items[0][tag_pos:(tag_pos+tag_len)]

                              # add tag to the corresponding start point                     
                              self.add_item_tag(0,                                   # Write to output port 0
                                               self.nitems_written(0)+out_produced,  # Index of the tag in absolute terms
                                               tag.key,                              # Key of the tag
                                               tag.value                             # Value of the tag
                                               )
                              #increase the number of output element produced counter
                              out_produced += tag_len

                          else: #tag_pos+tag_len >= len_out:
                              n_item_to_wrt = len_out - tag_pos
                              output_items[0][out_produced:(out_produced + n_item_to_wrt)] = input_items[0][tag_pos:(tag_pos+n_item_to_wrt)]

                              self.add_item_tag(0,                                     # Write to output port 0
                                                self.nitems_written(0)+out_produced,   # Index of the tag in absolute terms
                                                tag.key,                               # Key of the tag
                                                tag.value                              # Value of the tag
                                                )

                              self.previous_tag_n_remainder = tag_len - n_item_to_wrt
                              out_produced                 += n_item_to_wrt
                              self.consume(0,len_out)
                              return out_produced

              #if there is no tag exits
              self.consume(0,len_out)

              #recall that the first "if" state is producing element!
              return out_produced
    tag_name: '"preambleStart"'
  states: {}
- name: epy_block_6_0_0_0_0_0
  id: epy_block
  parameters:
    SF: SF
    _source_code: |-
      """
      Modulation Block:
      """

      import numpy as np
      from gnuradio import gr
      import math
      import pmt

      def modulate(SF, id, os_factor) :
          M  = pow(2,SF)
          n_fold = M * os_factor - id * os_factor
          chirp = np.zeros(M*os_factor, dtype=np.complex64)
          for n in range(0,M*os_factor):
              if n < n_fold:
                  chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-0.5)*n/os_factor))
              else:
                  chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-1.5)*n/os_factor))
          return chirp

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, SF = 9):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LoRa Modulation',   # will show up in GRC
                  in_sig=[np.uint32],
                  out_sig=[(np.complex64,pow(2,SF))]
              )
              self.SF = SF

          def work(self, input_items, output_items):
              
              symbols = input_items[0]

              for i in range (len(symbols)) :
                  output_items[0][i] = modulate(self.SF, symbols[i], 1)


              # tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              # #if there exist tag
              # if len(tags) > 0:
              #     #for each tag apply
              #     for tag in tags:
              #         tag_name   = pmt.to_python(tag.key)            # packet_tag
              #         tag_len    = pmt.to_python(tag.value)          # packet_len
              #         tag_pos    = tag.offset - self.nitems_read(0)  # packet_position_index
              #         print("tag_name :", tag_name, "\ntag_len :", tag_len, "\ntag_pos:", tag_pos)
              # debug
              print("\n--- GENERAL WORK : MODULATION ---")
              print("symbols :")
              print(symbols)
              return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 512*9+round(pow(2,SF)*(preamble_len+2.25))
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_stream_mux_0, '0', epy_block_6, '0']
- [blocks_stream_mux_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_mux_1, '0', epy_block_6, '0']
- [blocks_stream_to_vector_0, '0', epy_block_5, '0']
- [blocks_tagged_stream_align_1, '0', epy_block_6_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_1, '0']
- [blocks_vector_source_x_0_0_0_0, '0', blocks_file_sink_0_3, '0']
- [blocks_vector_source_x_0_0_0_0, '0', epy_block_1_0_0, '0']
- [blocks_vector_source_x_0_1, '0', epy_block_4, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_file_sink_4, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_stream_mux_1, '1']
- [blocks_vector_to_stream_0_0_1, '0', blocks_stream_mux_0, '1']
- [blocks_vector_to_stream_0_0_1, '0', blocks_stream_mux_1, '2']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0_1_0_0, '0', epy_block_6_0_0_0_0_0, '0']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_1_0_0, '0', epy_block_1_1, '0']
- [epy_block_1_1, '0', epy_block_0_1_0_0, '0']
- [epy_block_2, '0', blocks_file_sink_0_1, '0']
- [epy_block_3, '0', blocks_vector_to_stream_0_0_0, '0']
- [epy_block_3, '0', epy_block_6, '1']
- [epy_block_4, '0', blocks_file_sink_0_0, '0']
- [epy_block_5, '0', epy_block_0, '0']
- [epy_block_6, '0', blocks_file_sink_1, '0']
- [epy_block_6, '0', blocks_tag_debug_0, '0']
- [epy_block_6, '0', blocks_tagged_stream_align_1, '0']
- [epy_block_6_0, '0', blocks_file_sink_2_0, '0']
- [epy_block_6_0, '0', blocks_stream_to_vector_0, '0']
- [epy_block_6_0_0_0_0_0, '0', blocks_vector_to_stream_0_0_1, '0']

metadata:
  file_format: 1
