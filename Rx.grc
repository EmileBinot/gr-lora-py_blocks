options:
  parameters:
    generate_options: qt_gui
    id: Rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: CR
  id: variable
  parameters:
    value: '2'
  states: {}
- name: SF
  id: variable
  parameters:
    value: '9'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: int(125e3)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: int(868e6)
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: '18'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: '6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bandwidth
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: bandwidth
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: dumpOUT
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: pow(2,SF)
    type: complex
  states: {}
- name: blocks_tagged_stream_align_1
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"preamble_end"'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    CR: CR
    SF: SF
    _source_code: |-
      """
      Deinterleaving block
      Inverse of interleaving block.
      Reference : "Towards an SDR implementation of LoRa..." 2020 A.Marquet, N.Montavont, G.Papadopoulos)

      INPUT:
          - in_sig[0]: CR int32 input sequence
      OUTPUT:
          - out_sig[0]: SF bytes output sequence (4+CR useful bits per byte)
      """

      import numpy as np
      from gnuradio import gr

      class Deinterleaver(gr.basic_block):
          def __init__(self, SF=9, CR=2):
              gr.basic_block.__init__(self,
                  name="LoRa Deinterleaver",
                  in_sig=[np.uint32],
                  out_sig=[np.uint8])
              self.SF = SF
              self.CR = CR

          def forecast(self, noutput_items, ninputs) :
              #ninput_items_required[i] is the number of items that will be consumed on input port i
              ninput_items_required = [self.CR+4]*ninputs # we need CR+4 items to produce anything
              return ninput_items_required

          def general_work(self, input_items, output_items):
              
              if(len(input_items[0]) >= self.CR+4) :  # if we have enough items to process

                  in0 = input_items[0][:self.CR+4]    # input buffer reference

                  # formatting the input buffer
                  input_matrix = np.zeros((self.CR+4, self.SF), dtype=np.uint8)
                  for i in range(len(in0)):
                      bits_crop = [int(x) for x in bin(in0[i])[2:]]                               # convert to binary         
                      input_matrix[i][:] = ([0]*(self.SF-len(bits_crop)) + bits_crop)[-(self.SF):]    # crop to SF bits

                  # deinterleaving
                  output_matrix = np.zeros((self.SF, self.CR+4), dtype=np.uint8)
                  for i in range(0,(self.SF)) :
                      for j in range(0,(self.CR+4)) :
                          idi=self.CR+4-1-j
                          idj=(self.SF-1-i+(self.CR+4)-1-j)%self.SF
                          output_matrix[i][j]=input_matrix[idi][idj]

                  # to uint32
                  output_items[0][0:(self.SF)] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))

                  # # debug
                  # print("\n--- GENERAL WORK : DEINTERLEAVER ---")
                  # print("in0 :")
                  # print(in0)
                  # print("len(in0) (should be CR+4): ")
                  # print(len(in0))
                  # print("input_matrix (CR+4 x SF):")
                  # print(input_matrix)
                  # print("output_matrix (SF x CR+4 ):")
                  # print(output_matrix)
                  # print("output_items[0] = ")
                  # print(output_items[0][0:(self.SF)])
                  # print("return len(output_items[0]) (should be CR+4): ")
                  # print(len(output_items[0]))

                  self.consume(0, self.CR+4)  # consume inputs (should be CR+4)
                  return self.SF              # return produced outputs (should be SF)

              else :
                  return 0
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    CR: CR
    _source_code: |-
      """
      Hamming decoding block
      Forward Error Correction decoding block.
      Reference : "MIT EECS II : http://web.mit.edu/6.02/www/f2012/handouts/L05_slides.pdf"

      INPUT:
          - in_sig[0]: binary input sequence (4+CR useful bits per byte)
      OUTPUT:
          - out_sig[0]: binary output sequence (4 useful bits per byte)
      """

      import numpy as np
      from gnuradio import gr


      class HammingRx(gr.sync_block):
          def __init__(self, CR = 2):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Hamming Rx',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.CR = CR

          def decode(self, input_vect, CR_loc) : 

              output=input_vect

              if CR_loc == 1: # CR = 1, no error correction
                  
                  syndrome = input_vect[0] ^ input_vect[1] ^ input_vect[2] ^ input_vect[3] ^ input_vect[4]
                  output = input_vect

              if CR_loc == 2: # CR = 2, no error correction
                  
                  syndrome = np.zeros((2,1), dtype=np.uint8)
                  syndrome[0] = input_vect[0] ^ input_vect[1] ^ input_vect[2] ^ input_vect[5]
                  syndrome[1] = input_vect[1] ^ input_vect[2] ^ input_vect[3] ^ input_vect[4]
                  output = input_vect

              if CR_loc == 3: # CR = 3, 1 error correction is possible
                  
                  n = 4+CR_loc
                  k = 4

                  # compute syndrome of input_vect
                  Q = np.array([[0,1,1], [1,1,0], [1,1,1], [1,0,1]], np.uint8)
                  Id = np.identity(n-k, dtype=np.uint8)
                  H = np.concatenate((Q.transpose(), Id),axis=1)
                  syndrome = np.dot(input_vect[:], H.transpose())%2

                  # compute syndromes lookup table
                  tmp = np.zeros((1,n-k+4), dtype=np.uint8)
                  tmp2 = np.identity(n-k+4, dtype=np.uint8)
                  E = np.concatenate((tmp, tmp2),axis=0)
                  S = np.dot(E,H.transpose())%2   

                  for j in range(S.shape[1]):             # iterate through the syndromes lookup table
                      if np.array_equal(S[j],syndrome):   # if found, correct the input_vect
                          output = input_vect ^ E[j][:]

              if CR_loc == 4: # CR = 4, 1 error correction is possible, 2 error detection is possible
                  
                  n = 4+CR_loc
                  k = 4

                  # compute syndrome of input_vect
                  Q = np.array([[0,1,1,1], [1,1,0,1], [1,1,1,0], [1,0,1,1]], np.uint8)
                  Id = np.identity(n-k, dtype=np.uint8)
                  H = np.concatenate((Q.transpose(), Id),axis=1)
                  syndrome = np.dot(input_vect[:], H.transpose())%2


                  if np.array_equal(syndrome,np.array([0,0,0,0])):    # if no error, return input_vect
                      output = input_vect

                  else :

                      # compute parity bit
                      parity = input_vect[0] ^ input_vect[1] ^ input_vect[2] ^ input_vect[3] ^ input_vect[4] ^ input_vect[5] ^ input_vect[6] ^ input_vect[7]
                      
                      if parity : # 1 error correctable
                          output = self.decode(input_vect[:][0:7], 3) # correct the first 7 bits by sending them to the decoding function
              
                      else :  # 2 errors detected
                          pass
              return output[:][0:4] # return the first 4 bits (data bits)

          def work(self, input_items, output_items):

              in0 = input_items[0]    # input buffer reference
              out = output_items[0]   # output buffer reference
          
              output_matrix = np.zeros((len(in0), 4), dtype=np.uint8)
              input_matrix = np.zeros((len(in0), 4+self.CR), dtype=np.uint8)

              for i in range(len(in0)):
                  bits_crop = [int(x) for x in bin(in0[i])[2:]]                                       # convert to binary
                  input_matrix[i][:] = ([0]*(self.CR+4-len(bits_crop)) + bits_crop)[-(self.CR+4):]    # crop to 4+CR bits
                  output_matrix[i][:] = self.decode(input_matrix[i][:],self.CR)                       # send to decoding function

              # convert output matrix to uint8
              out[:] = output_matrix.dot(1 << np.arange(output_matrix.shape[-1] - 1, -1, -1))

              # # debug
              # print("\n--- GENERAL WORK : HAMMING_DEC ---")
              # print("in0 :")
              # print(in0)
              # print("input_matrix :")
              # print(input_matrix)
              # print("output_matrix :")
              # print(output_matrix)
              # print("out :")
              # print(out)
              # print("--- HAMMING_DEC END---")

              return len(output_items[0])
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Dewhitening block
      Remove white noise from the signal

      INPUT:
          - in_sig[0]: whitened binary input sequence
      OUTPUT:
          - out_sig[0]: output binary sequence with white noise removed
      """

      import numpy as np
      from gnuradio import gr

      whitening_seq =(0xFF, 0xFE, 0xFC, 0xF8, 0xF0, 0xE1, 0xC2, 0x85, 0x0B, 0x17, 0x2F, 0x5E, 0xBC, 0x78, 0xF1, 0xE3,
                      0xC6, 0x8D, 0x1A, 0x34, 0x68, 0xD0, 0xA0, 0x40, 0x80, 0x01, 0x02, 0x04, 0x08, 0x11, 0x23, 0x47,
                      0x8E, 0x1C, 0x38, 0x71, 0xE2, 0xC4, 0x89, 0x12, 0x25, 0x4B, 0x97, 0x2E, 0x5C, 0xB8, 0x70, 0xE0,
                      0xC0, 0x81, 0x03, 0x06, 0x0C, 0x19, 0x32, 0x64, 0xC9, 0x92, 0x24, 0x49, 0x93, 0x26, 0x4D, 0x9B,
                      0x37, 0x6E, 0xDC, 0xB9, 0x72, 0xE4, 0xC8, 0x90, 0x20, 0x41, 0x82, 0x05, 0x0A, 0x15, 0x2B, 0x56,
                      0xAD, 0x5B, 0xB6, 0x6D, 0xDA, 0xB5, 0x6B, 0xD6, 0xAC, 0x59, 0xB2, 0x65, 0xCB, 0x96, 0x2C, 0x58,
                      0xB0, 0x61, 0xC3, 0x87, 0x0F, 0x1F, 0x3E, 0x7D, 0xFB, 0xF6, 0xED, 0xDB, 0xB7, 0x6F, 0xDE, 0xBD,
                      0x7A, 0xF5, 0xEB, 0xD7, 0xAE, 0x5D, 0xBA, 0x74, 0xE8, 0xD1, 0xA2, 0x44, 0x88, 0x10, 0x21, 0x43,
                      0x86, 0x0D, 0x1B, 0x36, 0x6C, 0xD8, 0xB1, 0x63, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xF3, 0xE7, 0xCE,
                      0x9C, 0x39, 0x73, 0xE6, 0xCC, 0x98, 0x31, 0x62, 0xC5, 0x8B, 0x16, 0x2D, 0x5A, 0xB4, 0x69, 0xD2,
                      0xA4, 0x48, 0x91, 0x22, 0x45, 0x8A, 0x14, 0x29, 0x52, 0xA5, 0x4A, 0x95, 0x2A, 0x54, 0xA9, 0x53,
                      0xA7, 0x4E, 0x9D, 0x3B, 0x77, 0xEE, 0xDD, 0xBB, 0x76, 0xEC, 0xD9, 0xB3, 0x67, 0xCF, 0x9E, 0x3D,
                      0x7B, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFA, 0xF4, 0xE9, 0xD3, 0xA6, 0x4C, 0x99, 0x33, 0x66,
                      0xCD, 0x9A, 0x35, 0x6A, 0xD4, 0xA8, 0x51, 0xA3, 0x46, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
                      0x0E, 0x1D, 0x3A, 0x75, 0xEA, 0xD5, 0xAA, 0x55, 0xAB, 0x57, 0xAF, 0x5F, 0xBE, 0x7C, 0xF9, 0xF2,
                      0xE5, 0xCA, 0x94, 0x28, 0x50, 0xA1, 0x42, 0x84, 0x09, 0x13, 0x27, 0x4F, 0x9F, 0x3F, 0x7F)

      # # debug
      # whitening_seq_debug = 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF
      # whitening_seq = whitening_seq_debug

      class LoraDewhitening(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Dewhitening',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.table_idx = 0 # index of the whitening table cell to be used for whitening
              
          def work(self, input_items, output_items):

              in0 = input_items[0]    # input buffer
              out = output_items[0]   # output buffer

              input_matrix = np.zeros((len(in0), 4), dtype=np.uint8)
              for i in range(len(in0)):
                  bits_crop = [int(x) for x in bin(in0[i])[2:]]                       # convert to binary
                  input_matrix[i][:] = ([0]*(4-len(bits_crop)) + bits_crop)[-(4):]    # crop to 4 useful bits
                  
                  out_temp = in0[i] ^ whitening_seq[self.table_idx]   # dewhitening

                  bits_out_temp_crop = [int(x) for x in bin(out_temp)[2:]]                                # convert to binary
                  bits_out_temp_crop_norm = ([0]*(4-len(bits_out_temp_crop)) + bits_out_temp_crop)[-(4):] # crop to 4 useful bits

                  # binary to decimal conversion
                  output_items[0][i] = np.array(bits_out_temp_crop_norm).dot(1 << np.arange(np.array(bits_out_temp_crop_norm).shape[-1] - 1, -1, -1))

                  self.table_idx += 1                         # increment table index
                  if(self.table_idx == len(whitening_seq)):   # if table index is out of bounds, reset it
                      self.table_idx = 0

              # # debug
              # print("\n--- GENERAL WORK : DEWHITENING ---")
              # print("in0 :")
              # print(in0)
              # print("input_matrix :")
              # print(input_matrix)
              # print("out :")
              # print(output_items[0][:])
              # print("return len(out): ")
              # print(len(output_items[0]))
              # print("--- DEWHITENING END---")
              
              return len(output_items[0])
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    SF: '9'
    _source_code: |-
      """
      Preamble Generation Block:
      Reference : "Towards an SDR implementation of LoRa..." 2020 A.Marquet, N.Montavont, G.Papadopoulos)

      INPUT:
          - None
      OUTPUT:
          - out_sig[0]: IQ complex vector, length = M * os_factor * (preamble_len + 2.25)
      """

      import numpy as np
      from gnuradio import gr
      import math
      import time


      def modulate_vect(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = np.zeros((len(id),M*os_factor), dtype=np.complex64)
          for i in range(len(id)) :
              chirp[i] = fact1*np.exp(2j*math.pi*(id[i]/M)*ka)
          return chirp

      class PreambleGenerator(gr.sync_block):

          def __init__(self, SF = 9, preamble_len = 6):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Preamble Generator',
                  in_sig=None,
                  out_sig=[(np.complex64,round(pow(2,SF)*(preamble_len+2.25)))]   # !!! will cause problem if os_factor > 1 !!! 
              )
              self.SF = SF
              self.preamble_len = preamble_len

          def work(self, input_items, output_items):
              # t = time.time()
              preamble_up = np.reshape(modulate_vect(self.SF, [0]*self.preamble_len, 1, 1), -1)      # generate preamble_len upchirps
              preamble_down = np.reshape(np.conjugate(modulate_vect(self.SF, [0]*3, 1, 1)), -1)      # generate 3 downchirps
              output_items[0][0] = np.concatenate((preamble_up, preamble_down[0:int(2.25*pow(2,self.SF))])) # concatenate preamble_up and preamble_down[0:2.25*M]
              # elapsed = time.time() - t
              # print("\nPreambleGenerator: ", elapsed)
              return len(output_items[0])
    preamble_len: preamble_len
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    B: '250000'
    SF: SF
    _source_code: |
      """
      Demodulation Block:
      Reference : "Towards an SDR implementation of LoRa..." 2020 A.Marquet, N.Montavont, G.Papadopoulos)

      INPUT:
          - in_sig[0]: IQ complex vectors input sequence
      OUTPUT:
          - out_sig[0]: 
      """

      import numpy as np
      from gnuradio import gr
      import math

      # def modulate(SF, id, os_factor) :
      #     M  = pow(2,SF)
      #     n_fold = M * os_factor - id * os_factor
      #     chirp = np.zeros(M*os_factor, dtype=np.complex64)
      #     for n in range(0,M*os_factor):
      #         if n < n_fold:
      #             chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-0.5)*n/os_factor))
      #         else:
      #             chirp[n] = np.exp(2j*math.pi *(n*n/(2*M)/pow(os_factor,2)+(id/M-1.5)*n/os_factor))
      #     return chirp

      def modulate(SF, id, os_factor, sign) :
          M  = pow(2,SF)
          ka = np.arange(0,M)
          fact1 = np.exp(1j*sign*math.pi*(pow(ka,2))/M)
          chirp = fact1*np.exp(2j*math.pi*(id/M)*ka)

          return chirp

      class Demodulation(gr.sync_block):

          def __init__(self, SF = 9, B = 250000):
              gr.sync_block.__init__(
                  self,
                  name='LoRa Demodulation',
                  in_sig=[(np.complex64,pow(2,SF))],
                  out_sig=[np.uint32]
              )
              self.SF = SF
              self.B = B

          def work(self, input_items, output_items):

              M = pow(2,self.SF)
              # base_upchirp = modulate(self.SF, 0, 1)
              base_downchirp = modulate(self.SF, 0, 1, -1)
              freq_vect = np.arange(0,M)                                    # !!!! WILL INTRODUCE PROBLEMS WHEN OS_FACTOR IS NOT 1 !!!!

              for i in range(len(input_items[0])):
                  demod_signal = np.multiply(input_items[0][i], base_downchirp)   # multiply every symbol with the downchirp
                  demod_signal_fft = np.fft.fft(demod_signal)                     # perform FFT on demodulated signal    
                  idx = np.argmax(np.abs(demod_signal_fft))                       # find the frequency index of the maximum value
                  output_items[0][i] = round(round(freq_vect[idx]))               # convert the frequency index to symbol index

              # debug
              print("\n--- GENERAL WORK : DEMODULATION ---")
              print("output_items[0][0:i] :")
              print(output_items[0][0:i])

              return len(output_items[0])
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    SF: SF
    _source_code: |-
      """
      Frame sync block:
      Tries to find a correlation peak between the input sequence and a reference sequence (preamble). If found, tag the end of preamble.

      INPUTS:
          - in_sig[0]: IQ complex input stream
          - in_sig[1]: IQ complex reference vector (preamble)
      OUTPUT:
          - out_sig[0]: IQ complex stream
      """


      import numpy as np
      from gnuradio import gr
      import pmt

      class Frame_sync(gr.basic_block):
          def __init__(self, SF=9, preamble_len = 6, frame_length = 18):
              gr.basic_block.__init__(self,
                  name="LoRa Frame Detector",
                  in_sig=[np.complex64,(np.complex64, round(pow(2,SF)*(preamble_len+2.25)))], # first input is the input signal, second is the preamble to be correlated with
                  # out_sig=[(np.complex64,pow(2,SF))])
                  out_sig=[(np.complex64)])
              self.SF = SF
              self.full_preamble_length = round(pow(2,SF)*(preamble_len+2.25))
              self.frame_length = round(pow(2,SF)*(frame_length))

          def forecast(self, noutput_items, ninputs) :
              ninput_items_required = [1]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
              return ninput_items_required

          def general_work(self, input_items, output_items):

              # buffer references
              in0 = input_items[0] # input signal
              in1 = input_items[1] # preamble to be correlated with
              out = output_items[0] # output buffer

              corr = np.correlate(in0[:], in1[0]) # correlate input signal with preamble
              peak = np.max(corr)                 # find the correlation peak
              threshold = 2000                    # threshold for peak detection

              if peak > threshold :
                  # print("peak > threshold")
                  peak_index = np.argmax(corr)         # get index of the peak
                  # add tag at the end of the preamble, write frame_length inside so Tagged Stream Cropper block can remove preamble
                  self.add_item_tag(0, self.nitems_written(0) + peak_index + self.full_preamble_length,  pmt.intern("preamble_end"),  pmt.intern(str(self.frame_length)))

                  # # debug
                  # print("\n--- Correlator ---")
                  # print("Peak: ", peak)
                  # print("Peak Index: ", peak_index)
                  # print("output_items[0]: ", len(output_items[0]))


              out[0:len(in0)] = in0[:len(out)]
              self.consume(0, len(in0[:len(out)]))
              return len(in0[:len(out)])
    frame_length: frame_len
    preamble_len: preamble_len
  states: {}
- name: epy_block_6_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Tagged Stream Cropper:
      Reference : https://dsp.stackexchange.com/questions/80751/gnu-radiotagged-stream-how-to-clip-the-stream-as-packet-length-tag-long

      INPUTS:
          - in_sig[0]: IQ complex stream
      OUTPUT:
          - out_sig[0]: IQ complex stream
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class my_basic_adder_block(gr.basic_block):
          def __init__(self,tag_name = 'packet_len'):
              gr.basic_block.__init__(self,
                                      name="Tagged Stream Cropper",
                                      in_sig  = [np.complex64],
                                      out_sig = [np.complex64])

              self.previous_tag_n_remainder = 0
              self.tag_name                 = tag_name
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def general_work(self, input_items, output_items):
              len_out = len(output_items[0])

              # DO PROCESSING
              out_produced = 0 # output produced 

              #-> Write the remaining data of the previous tag
              if self.previous_tag_n_remainder > 0: 
                  if self.previous_tag_n_remainder < len_out: # if the length of the input items is sufficient to write the remainder of the previous tag items 
                      output_items[0][:self.previous_tag_n_remainder] = input_items[0][:self.previous_tag_n_remainder] #write to output 
                      out_produced                                   += self.previous_tag_n_remainder                  #inccrease the number of item produced
                      self.previous_tag_n_remainder = 0                                                                #reset the counter 
                      # the RETURN is at the end of the work()

                  else: # self.previous_tag_n_remainder >= len_out
                      output_items[0][:len_out]      = input_items[0][:len_out]
                      self.previous_tag_n_remainder -= len_out
                      self.consume(0, len_out)
                      return len_out

              # READ TAGS AND PARSE THE RECEIVED STREAM
              tags = self.get_tags_in_window(0, out_produced, len_out)

              #if there exist tag
              if len(tags) > 0:
                  #for each tag apply
                  for tag in tags:
                      tag_name   = pmt.to_python(tag.key)            # packet_tag
                      tag_len    = int(pmt.to_python(tag.value))          # packet_len
                      tag_pos    = tag.offset - self.nitems_read(0)  # packet_position_index
                      if tag_name == self.tag_name:       #check if the tag name is appropriate
                          if tag_pos + tag_len < len_out: # if all the elements correspding to the "tag" are included in the input_items

                              # write the elements to the output
                              output_items[0][out_produced:(out_produced+tag_len)] = input_items[0][tag_pos:(tag_pos+tag_len)]

                              # add tag to the corresponding start point                     
                              self.add_item_tag(0,                                   # Write to output port 0
                                               self.nitems_written(0)+out_produced,  # Index of the tag in absolute terms
                                               tag.key,                              # Key of the tag
                                               tag.value                             # Value of the tag
                                               )
                              #increase the number of output element produced counter
                              out_produced += tag_len

                          else: #tag_pos+tag_len >= len_out:
                              n_item_to_wrt = len_out - tag_pos
                              output_items[0][out_produced:(out_produced + n_item_to_wrt)] = input_items[0][tag_pos:(tag_pos+n_item_to_wrt)]

                              self.add_item_tag(0,                                     # Write to output port 0
                                                self.nitems_written(0)+out_produced,   # Index of the tag in absolute terms
                                                tag.key,                               # Key of the tag
                                                tag.value                              # Value of the tag
                                                )

                              self.previous_tag_n_remainder = tag_len - n_item_to_wrt
                              out_produced                 += n_item_to_wrt
                              self.consume(0,len_out)
                              return out_produced

              #if there is no tag exits
              self.consume(0,len_out)

              #recall that the first "if" state is producing element!
              return out_produced

      # """
      # Preamble removal block
      # Correlation method
      # """

      # import numpy as np
      # from gnuradio import gr
      # import pmt

      # class Preamble_Remover(gr.basic_block):
      #     def __init__(self, SF=9, preamble_len = 6):
      #         gr.basic_block.__init__(self,
      #             name="LoRa Preamble Remover",
      #             in_sig=[(np.complex64)],
      #             out_sig=[(np.complex64)])
      #         self.SF = SF

      #     def forecast(self, noutput_items, ninputs) :
      #         ninput_items_required = [1]*ninputs #ninput_items_required[i] is the number of items that will be consumed on input port i
      #         return ninput_items_required

      #     def general_work(self, input_items, output_items):

      #         #buffer references
      #         in0 = input_items[0] #input signal

      #         tags = self.get_tags_in_window(0, 0, len(input_items[0]))
      #         for tag in tags:
      #             key = pmt.to_python(tag.key) # convert from PMT to python string
      #             value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
      #             print('key:', key)
      #             print('value:', value, type(value))
      #             print('')
      #             croppedInput = in0[int(value):]
      #             output_items[0][0:len(in0)] = croppedInput[:len(output_items[0])]
      #             self.consume(0, len(in0[:len(output_items[0])]))
      #         return len(in0[:len(output_items[0])])
    tag_name: '"preamble_end"'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bandwidth
    center_freq0: center_freq
    dev_addr: '"addr=192.168.10.2"'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', epy_block_5, '0']
- [blocks_tagged_stream_align_1, '0', epy_block_6_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_2, '0', blocks_file_sink_0_1, '0']
- [epy_block_2, '0', blocks_null_sink_0, '0']
- [epy_block_3, '0', epy_block_6, '1']
- [epy_block_5, '0', epy_block_0, '0']
- [epy_block_6, '0', blocks_tagged_stream_align_1, '0']
- [epy_block_6_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', epy_block_6, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
